# Keil uVision project car_freertos_LP_MSPM0G3507.uvprojx, settings and files
target car_freertos_LP_MSPM0G3507 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: car_freertos_LP_MSPM0G3507 +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P../generated' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../config,../generated,../bsp,../bsp/gpio,../bsp/pwm,../bsp/encoder,../bsp/time,../bsp/spi,../bsp/log,../bsp/freertos,../module,../application,../../kernel/freertos/Source,../../kernel/freertos/Source/include,../../kernel/freertos/Source/portable/TI_ARM_CLANG/ARM_CM0,../../source,../../source/third_party/CMSIS/Core/Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Application
    ../: main.c
    ../application/: app_init.c motor_control_task.c command_task.c safety_task.c ui_task.c log_task.c
    ../bsp/gpio/: bsp_gpio.c
    ../bsp/pwm/: bsp_pwm.c
    ../bsp/encoder/: bsp_encoder.c
    ../bsp/time/: bsp_time.c
    ../bsp/spi/: bsp_spi.c
    ../bsp/log/: bsp_log.c
    ../bsp/freertos/: bsp_freertos.c
    ../bsp/buzzer/: bsp_buzzer.c
    ../bsp/ws2812/: bsp_ws2812.c
    ../generated/: empty.syscfg ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group Module
    ../module/: tb6612_motor.c encoder_ab.c speed_pid.c safety.c st7735_ui.c
  group FreeRTOS Kernel
    ../../kernel/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../kernel/freertos/Source/portable/MemMang/: heap_4.c
    ../../kernel/freertos/Source/portable/TI_ARM_CLANG/ARM_CM0/: port.c portasm.c
  group TI DPL FreeRTOS
    ../../kernel/freertos/dpl/: AppHooks_freertos.c ClockP_freertos.c DebugP_freertos.c MutexP_freertos.c SemaphoreP_freertos.c SystemP_freertos.c StaticAllocs_freertos.c TaskP_freertos.c HwiPMSPM0_freertos.c
